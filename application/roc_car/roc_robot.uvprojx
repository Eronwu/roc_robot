# Keil uVision project roc_robot.uvprojx, settings and files
target rt-thread_stm32l4xx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32l4xx
  AfterMake: fromelf --bin !L --output rt-thread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32L475xx, RT_USING_ARM_LIBC
  c include: .;..\..\rt-thread\include;.;.\applications;packages\EasyFlash-v3.2.1\inc;ports\easyflash;packages\fal-v0.2.0\inc;ports\fal;.\packages\stm32_sdio-v1.0.2;ports\wifi;..\..\libraries\wifi;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m4;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\dfs\filesystems\devfs;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\spi\sfud\inc;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\wlan;..\..\rt-thread\components\finsh;..\..\rt-thread\components\libc\compilers\armlibc;..\..\rt-thread\components\libc\compilers\common;..\..\rt-thread\components\net\lwip-2.0.2\src;..\..\rt-thread\components\net\lwip-2.0.2\src\include;..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4;..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include;..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif;..\..\rt-thread\components\net\lwip-2.0.2\src\include\posix;..\..\libraries\CMSIS\Device\ST\STM32L4xx\Include;..\..\libraries\CMSIS\Include;..\..\libraries\STM32L4xx_HAL_Driver\inc;..\..\libraries\rt_ota\inc;..\..\drivers;.\packages\rt-robot-latest\chassis;.\packages\rt-robot-latest\controller;.\packages\rt-robot-latest\encoder;.\packages\rt-robot-latest\kinematics;.\packages\rt-robot-latest\motor;.\packages\rt-robot-latest\protocol;.\packages\rt-robot-latest\robot;.\packages\rt-robot-latest\wheel;..\..\rt-thread\components\drivers\include\ipc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    ./applications/: protocol_parser.c roc_robot.c wifi_connect.c tcprecv.c
  group EasyFlash
    packages/EasyFlash-v3.2.1/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-v0.2.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c fal_flash_stm32l4_port.c
  group stm32_sdio
    ./packages/stm32_sdio-v1.0.2/: stm32_sdio.c
  group wifi
    ports/wifi/: wifi_config.c
    ../../libraries/wifi/: libwifi_6181_0.2.4_armcm4_keil.lib
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../rt-thread/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group STM32L4xx_HAL_Driver
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    ../../libraries/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_qspi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group rt_ota
    ../../libraries/rt_ota/libs/: librt_ota_noalgo_0.1.2_stm32l4_keil.lib
  group Drivers
    ../../drivers/: board.c drv_clock.c drv_gpio.c drv_qspi_flash.c drv_usart.c drv_sdio_adapter.c drv_qspi.c drv_wlan.c drv_pwm.c
  group robot
    ./packages/rt-robot-latest/chassis/: chassis.c
    ./packages/rt-robot-latest/controller/: controller.c inc_pid_controller.c pos_pid_controller.c
    ./packages/rt-robot-latest/encoder/: ab_phase_encoder.c encoder.c single_phase_encoder.c
    ./packages/rt-robot-latest/kinematics/: kinematics.c
    ./packages/rt-robot-latest/motor/: dual_pwm_motor.c motor.c single_pwm_motor.c
    ./packages/rt-robot-latest/protocol/: command.c ps2.c
    ./packages/rt-robot-latest/robot/: mobile_robot.c robot.c
    ./packages/rt-robot-latest/wheel/: wheel.c
software components: CMSIS:CORE 5.0.1
